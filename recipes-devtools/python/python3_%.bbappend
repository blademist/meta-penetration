FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

FILES_${PN}-netclient += "${libdir}/python${PYTHON_BASEVERSION}/webbrowser.*"

