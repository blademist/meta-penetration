FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

QT_CONFIG_FLAGS_remove = " -icu"
