FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://wext.cfg \
            file://carl9170.cfg \
            "

